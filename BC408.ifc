Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2020-03-06T09:42:27
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 06 09:42:27 2020 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{09DB6481-9B3F-4F9E-BDE3-FE9BA6B4A63D}\ifc * Database version: 5507 * Database creation date: Fri Mar 06 09:42:25 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 06 09:42:26 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 06 09:42:26 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2020 BIM\03$MARCH\BC408.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Building Story: yes; Structural: no; Name: Level 1
Dimensions - Computation Height: 0 mm
Graphics - Symbol at End 2 Default: yes; Line Pattern: -3000010; Symbol at End 1 Default: no; Line Weight: 1; Color: 0

# IfcBuildingElementProxy: BC408 Dolphin Stainless Steel Coat Hook, BC408:BC408 Dolphin Stainless Steel Coat Hook:43407
In: Level 1
Material: Stainless Steel
Constraints - Offset: 0 mm; Level: Level: Level 1; Host: Level : Level 1; Moves With Nearby Elements: no
Dimensions - Volume: 0.0000125405 m3; Diameter: Ø19mm; Projection: 50mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Limited
Pset_BuildingElementProxyCommon - Reference: BC408 Dolphin Stainless Steel Coat Hook
Materials and Finishes - Finish: Satin stainless steel
Identity Data - URL: www.dolphinsolutions.co.uk; Email: info@dolphinsolutions.co.uk; Description: Stainless Steel Coat Hook; Address: Southpoint, Compass Park, Bodiam, Robertsbridge, TN32 5BS; Model: Coat Hook; Manufacturer: Dolphin Solutions Limited; Assembly Description: Other Plumbing Fixtures; Tel No.: +44 (0) 1424 202224; Assembly Code: D2010900; Fax No.: +44 (0) 1424 205200
General - Product Data: Stainless steel construction; Product Code: Satin stainless steel = BC408 / Polished stainless steel = BC408B; Product Page Link: https://www.dolphinsolutions.co.uk/product/dolphin-stainless-steel-coat%e2%80%88hook/
